# Keil uVision project 沧海，&横流.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 沧海，&横流 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\library\FreeRTOS\include;..\library\FreeRTOS\portable\RVDS\ARM_CM3;..\core;..\groundwork\LED;..\library\STM32F10x_StdPeriph_Driver\inc;..\library\SYSTEM\delay;..\library\SYSTEM\sys;..\library\SYSTEM\usart;..\user\inc;..\user\inc;..\groundwork\LED;..\groundwork\USART;..\groundwork\IIC;..\modules\INA226;..\algorithm\CRC_Protocol;..\algorithm\Protocol;..\application;..\groundwork\CAN
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../core/: core_cm3.c startup_stm32f10x_md.s
  group Freertos\core
    ../library/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS\portable
    ../library/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../library/FreeRTOS/portable/MemMang/: heap_4.c
  group application
    ../application/: ina226_task.c
  group algorithm
    ../algorithm/CRC_Protocol/: bsp_crc8.c bsp_crc16.c
    ../algorithm/Protocol/: bsp_protocol.c
  group stdperiph_driver
    ../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group system
    ../library/SYSTEM/sys/: sys.c
    ../library/SYSTEM/delay/: delay.c
  group user
    ../user/src/: main.c start_task.c stm32f10x_it.c system_stm32f10x.c
  group groundwork
    ../groundwork/LED/: bsp_led.c
    ../groundwork/USART/: bsp_usart.c
    ../groundwork/IIC/: bsp_iic.c
    ../groundwork/CAN/: bsp_can.c
  group modules
    ../modules/INA226/: bsp_ina226.c
